Commit message: added variable

File: urdf/robot_parameters.xacro (robot description, xacro)
@@ -24,3 +24,4 @@
   <xacro:property name="camera_name" value="kinnect" />
   <xacro:property name="frame_name" value="camera_link" />
+  <xacro:property name="M_PI" value="3.14" />
 </robot>
